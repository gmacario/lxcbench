# Prevent create-ade to fail

ALLOW_EMPTY_${PN} = "1"

# === EOF ===
